## arch/arm64/hotplug/Kconfig
```kconfig
config AUTOSMP_HOTPLUG
	bool "Enable AutoSMP cpu hotplug driver"
	default n
	help
	  AutoSMP cpu hotplug driver for ARM SOCs
```
